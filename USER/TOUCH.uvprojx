# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=188 --diag_suppress=223 --diag_suppress=546  --diag_suppress=1295
  c include: ..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MIDWARE\LVGL\src;..\MIDWARE\LVGL\examples\porting;..\MIDWARE\LVGL;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\DISP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
    ../MIDWARE/LVGL/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f407xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/TOUCH/: ctiic.c touch.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DISP/: disp.c
  group MIDWARE/LVGL/Src
    ../MIDWARE/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../MIDWARE/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../MIDWARE/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../MIDWARE/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../MIDWARE/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../MIDWARE/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../MIDWARE/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../MIDWARE/LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../MIDWARE/LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../MIDWARE/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../MIDWARE/LVGL/src/extra/: lv_extra.c
    ../MIDWARE/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../MIDWARE/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../MIDWARE/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../MIDWARE/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../MIDWARE/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../MIDWARE/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../MIDWARE/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../MIDWARE/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../MIDWARE/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../MIDWARE/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../MIDWARE/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../MIDWARE/LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../MIDWARE/LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../MIDWARE/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../MIDWARE/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../MIDWARE/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../MIDWARE/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../MIDWARE/LVGL/src/extra/others/msg/: lv_msg.c
    ../MIDWARE/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../MIDWARE/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../MIDWARE/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../MIDWARE/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../MIDWARE/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../MIDWARE/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../MIDWARE/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../MIDWARE/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../MIDWARE/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../MIDWARE/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../MIDWARE/LVGL/src/extra/widgets/led/: lv_led.c
    ../MIDWARE/LVGL/src/extra/widgets/list/: lv_list.c
    ../MIDWARE/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../MIDWARE/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../MIDWARE/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../MIDWARE/LVGL/src/extra/widgets/span/: lv_span.c
    ../MIDWARE/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../MIDWARE/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../MIDWARE/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../MIDWARE/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../MIDWARE/LVGL/src/extra/widgets/win/: lv_win.c
    ../MIDWARE/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../MIDWARE/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../MIDWARE/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group MIDWARE/LVGL/Font
    ../MIDWARE/LVGL/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c
  group MIDWARE/LVGL/Port
    ../MIDWARE/LVGL/examples/porting/: lv_port_disp.c lv_port_indev.c
    ../MIDWARE/LVGL/: lv_conf.h
